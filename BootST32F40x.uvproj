# Keil uVision project BootST32F40x.uvproj, settings and files
target BootST32F40x (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: BootST32F40x +hex
  AfterMake: fromelf --bin !L --output Boot.bin
  c flags: Optim=4 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --inline --remove sstream.L
  group Source
    ./src/: Debug.c stm32f4xx_flash.c startup_stm32f4xx.S Hardware.c main.c system_stm32f4xx.c
